<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\fpu_fft_example_s132_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s132\iar\fpu_fft_example_s132_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\fpu_fft_example_blank_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\fpu_fft_example_blank_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s132_irq\iar\fpu_fft_example_s132_pca10056_irq.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s132_irq\iar\fpu_fft_example_s132_pca10040_irq.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\blank_irq\iar\fpu_fft_example_blank_pca10056_irq.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank_irq\iar\fpu_fft_example_blank_pca10040_irq.ewp</path>
  </project>  <batchBuild/>
</workspace>