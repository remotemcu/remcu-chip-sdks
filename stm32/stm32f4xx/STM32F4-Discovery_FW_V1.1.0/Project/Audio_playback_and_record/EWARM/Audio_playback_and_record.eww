<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Audio_playback_and_record.ewp</path>
  </project>
  <batchBuild/>
</workspace>


