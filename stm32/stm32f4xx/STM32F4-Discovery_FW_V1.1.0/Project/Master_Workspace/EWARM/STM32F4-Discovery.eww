<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC3_DMA\EWARM\ADC3_DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\ADC_Interleaved_DMAmode2\EWARM\ADC_Interleaved_DMAmode2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Audio_playback_and_record\EWARM\Audio_playback_and_record.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DAC_SignalsGeneration\EWARM\DAC_SignalsGeneration.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\DMA_FLASH_RAM\EWARM\DMA_FLASH_RAM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\EXTI\EWARM\Exti.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Program\EWARM\Flash_Program.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\FLASH_Write_Protection\EWARM\Flash_Write_Protection.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IO_Toggle\EWARM\IO_Toggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\IWDG\EWARM\IWDG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\MEMS\EWARM\LIS302DL.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_CurrentConsumption\EWARM\PWR_CurrentConsumption.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STANDBY\EWARM\PWR_STANDBY.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\PWR_STOP\EWARM\PWR_STOP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\RCC\EWARM\RCC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Demonstration\EWARM\STM32F4-Discovery_Demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\FW_upgrade\EWARM\STM32F4-Discovery_FW_Upgrade.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\SysTick\EWARM\SysTick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_ComplementarySignals\EWARM\TIM_ComplementarySignals.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Input\EWARM\TIM_PWM_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_PWM_Output\EWARM\TIM_PWM_Output.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Peripheral_Examples\TIM_TimeBase\EWARM\TIM_TimeBase.ewp</path>
  </project>
  <batchBuild/>
</workspace>


